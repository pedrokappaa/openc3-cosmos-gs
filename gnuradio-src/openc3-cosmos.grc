options:
  parameters:
    author: Pedro Andrade
    generate_options: qt_gui
    id: gnuradio_openc3
    output_language: python
    run_options: run
    title: Interfacing with OpenC3 COSMOS
  states: {}

blocks:
- name: FREQ_RX
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: FREQ_TX
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: ON_SIGHT
  id: variable
  parameters:
    value: '0'
  states: {}
- name: SAMPLE_RATE
  id: variable
  parameters:
    value: '5000000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: FREQ_RX
    offset: '0'
    phase: '0'
    samp_rate: SAMPLE_RATE
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: FREQ_TX
    offset: '0'
    phase: '0'
    samp_rate: SAMPLE_RATE
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: gnuradio-src/tcp_dump.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("pkt")
    file: gnuradio-src/packet.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: FREQ_TX
  states: {}
- name: blocks_msgpair_to_var_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: FREQ_RX
  states: {}
- name: blocks_msgpair_to_var_0_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: ON_SIGHT
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: int(ON_SIGHT)
    type: complex
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: int(ON_SIGHT)
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"pkt_len"'
    packet_len: '72'
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: SAMPLE_RATE
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: SAMPLE_RATE
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class command_parser(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="Command parser",
                  in_sig=[],
                  out_sig=[])
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out_ON_SIGHT"))
              self.message_port_register_out(pmt.intern("out_FREQ_RX"))
              self.message_port_register_out(pmt.intern("out_FREQ_TX"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg_pdu):
              data = pmt.cdr(msg_pdu)

              if pmt.is_u8vector(data):
                  msg = bytes(pmt.u8vector_elements(data)).decode("utf-8").strip()

                  if msg == "aos":
                      self.publish_var("ON_SIGHT", 1)

                  elif msg == "los":
                      self.publish_var("ON_SIGHT", 0)

                  elif msg.startswith("freq_rx"):
                      try:
                          _, value = msg.split()
                          freq = int(value)
                          self.publish_var("FREQ_RX", freq)
                      except Exception as e:
                          print("Error parsing freq_rx:", e)

                  elif msg.startswith("freq_tx"):
                      try:
                          _, value = msg.split()
                          freq = int(value)
                          self.publish_var("FREQ_TX", freq)
                      except Exception as e:
                          print("Error parsing freq_tx:", e)

          def publish_var(self, key_str, val_int):
              key = pmt.intern(key_str)
              val = pmt.from_long(val_int)
              pair = pmt.cons(key, val)
              self.message_port_pub(pmt.intern(f"out_{key_str}"), pair)
              print(f"{key_str} : {val_int}")
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '256'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: note_0
  id: note
  parameters:
    note: This source is simulating the SDR + LoRa demodulation pipeline, from RF to binary data
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: pkt_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: ''
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: SAMPLE_RATE
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: SAMPLE_RATE
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [blocks_file_source_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_selector_0_0, '0', blocks_null_sink_0_0, '0']
- [blocks_selector_0_0, '1', qtgui_freq_sink_x_0, '0']
- [blocks_selector_0_0_0, '0', blocks_null_sink_0_0_0, '0']
- [blocks_selector_0_0_0, '1', qtgui_freq_sink_x_0_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle_0, '0', blocks_selector_0_0, '0']
- [blocks_throttle_0_0, '0', blocks_selector_0_0_0, '0']
- [epy_block_0, out_FREQ_RX, blocks_msgpair_to_var_0_0, inpair]
- [epy_block_0, out_FREQ_TX, blocks_msgpair_to_var_0, inpair]
- [epy_block_0, out_ON_SIGHT, blocks_msgpair_to_var_0_0_0, inpair]
- [network_socket_pdu_0, pdus, epy_block_0, in]
- [network_socket_pdu_0, pdus, pdu_pdu_to_stream_x_0, pdus]
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, network_socket_pdu_0, pdus]
- [pdu_tagged_stream_to_pdu_0_0, pdus, network_socket_pdu_0, pdus]

metadata:
  file_format: 1
